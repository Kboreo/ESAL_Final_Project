# Keil uVision project project.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin --output .\rvmdk\project.bin .\rvmdk\project.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..\..;.\driverlib;.\src;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: project.sct
  link misc: --entry Reset_Handler
  group Source
    ./: project.c project.h startup_rvmdk.S
  group Libraries
    ./inc/: driverlib.lib
  group Documentation
    ./: README.txt
  group src
    ./: Encoder.h Encoder.c myPWM.h myPWM.c Float_Setup.h Float_Setup.c Read_Encoder.c Read_Encoder.h Speed_Control.c Speed_Control.h Get_Speed.c Get_Speed.h Calibrate.c Calibrate.h HAL_ADC.c HAL_ADC.h myGPIO.c myGPIO.h i2c.c
    ./src/: Uart_helper.c Uart_helper.h
software components: CMSIS:CORE 5.0.1
